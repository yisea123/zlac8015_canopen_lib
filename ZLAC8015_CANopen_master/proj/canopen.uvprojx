# Keil uVision project canopen.uvprojx, settings and files
target canopen (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: canopen +hex
  c flags: Optim=2 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,CAN_SLAVE_BOARD
  c include: ..\proj;..\start-up;..\STM32F10x_StdPeriph_Driver\inc;..\driver\usart1;..\driver\can;..\canfestival\inc\STM32;..\canfestival\inc;..\canfestival-stm32;..\can-slave;..\driver\Modbus;..\FreeModbus\port;..\FreeModbus\modbus\ascii;..\FreeModbus\modbus\functions;..\FreeModbus\modbus\include;..\FreeModbus\modbus\rtu;..\FreeModbus\modbus\tcp
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group proj
    ./: MAIN.C stm32f10x_it.c system_stm32f10x.c delay.c sys.c
  group core
    ../core/: core_cm3.c
  group start-up
    ../start-up/: startup_stm32f10x_hd.s
  group driver
    ../driver/can/: direct_can.c
    ../driver/usart1/: usart1.c
  group std-fwlib
    ../STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_exti.c
  group canfestival
    ../canfestival/src/: dcf.c emcy.c lifegrd.c lss.c nmtMaster.c nmtSlave.c objacces.c pdo.c sdo.c states.c sync.c timer_canfestival.c
  group canfestival-stm32
    ../canfestival-stm32/: STM32_timer_canfestival.c
  group can-master
    ../can-slave/: Master.c Master_board.c TestMaster.c
